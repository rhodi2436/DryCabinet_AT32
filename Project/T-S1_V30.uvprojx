# Keil uVision project T-S1_V30.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: AT32F403AVET7 ArteryTek
  pack: Keil.AT32F4xx_DFP.1.3.7
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 2026_03_20 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F403AVCT7,USE_STDPERIPH_DRIVER,
  c include: ..\Libraries\AT32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\CM4\CoreSupport;..\Libraries\CMSIS\CM4\DeviceSupport;.\QRcode;.\Head File;.\USER_DRV;.\USER_APP;.\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group USER
    ./USER_APP/: TFT3.55.c main.c process.c crc.c Interrupt.c SHT3x.c Movement.c
    ./USER_DRV/: Beep.c Key.c led.c Usart_Module.c SPIM_NorFlash.c iic_key.c eeprom.c
  group BSP
    ./BSP/: T-S1_V30_board.c T-S1_V30_board.h
  group HeadFile
    ./Head File/: ASCII_2040B.h Bell.h CHAR_1016.h CHAR_1324.h CHAR_1632.h CHAR_1940.h CHAR_2040B.h CHAR_3264B.h CHAR_3572B.h CHAR_3572B2.h CHAR_4080.h CHAR_4080B.h CHAR_54112B.h China_Dot_lib.h Dot_Lib.h FSMC_SRAM.h Glob.h Image_Const.h includes.h InfoImage_Lib.h Key.h led.h Main.h my_spi.h process.h RTC.h spi_flash.h TFT3.55.h Typedef.h sht3x.h iic_key.h Movement.h eeprom.h
  group CMSIS
    ./: system_at32f4xx.c
    ../Libraries/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f403vx_hd.s
  group AT32Periph
    ../Libraries/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_gpio.c at32f4xx_tim.c at32f4xx_rcc.c at32f4xx_usart.c at32f4xx_xmc.c misc.c at32f4xx_flash.c at32f4xx_exti.c at32f4xx_i2c.c
  group README
    ./: readme.txt
  group QRcode
    ./QRcode/: bitstream.c mask.c mmask.c mqrspec.c QR_Encode.c qrencode.c qrinput.c qrspec.c rscode.c split.c
